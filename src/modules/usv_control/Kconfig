## src/modules/usv_control/Kconfig
```kconfig
menuconfig MODULES_USV_CONTROL
	bool "usv_control"
	default n
	---help---
		Enable support for USV manual control
```
